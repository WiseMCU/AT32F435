# Keil uVision project rt_nano.uvprojx, settings and files
target AT32F435_RT_NANO (6160000::V6.16::ARMCLANG)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt_nano +hex
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\applications\inc;.\drivers;.\drivers\f435_437;.\libraries\f435_437\drivers\inc;.\libraries\f435_437\cmsis\cm4\core_support;.\libraries\f435_437\cmsis\cm4\device_support;.\rt-thread\components\finsh;.\rt-thread\include;.\RTT\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group applications
    ./applications/src/: main.c
  group drivers
    ./drivers/: rtconfig.h board.c
    ./drivers/f435_437/: drv_clk.c drv_common.c drv_usart.c
  group libraries
    ./libraries/f435_437/drivers/: startup_at32f435_437.s system_at32f435_437.c
    ./libraries/f435_437/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group rt_components
    ./rt-thread/components/finsh/: cmd.c msh.c shell.c
  group rt_libcpu
    ./rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group rt_src
    ./rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group segger
    ./RTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
