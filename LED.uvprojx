# Keil uVision project LED.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\Core\inc;.\Drivers\inc;.\BSP\inc;.\RTT\inc;.\User\inc;.\libraries\cmsis\cm4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group User
    ./Core/src/: main.c at32f435_437_clock.c
    ./User/src/: user.c
  group RTT
    ./RTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group BSP
    ./BSP/src/: gpio.c i2c.c sys.c
  group Driver
    ./Drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
    ./Drivers/: startup_at32f435_437.s system_at32f435_437.c
